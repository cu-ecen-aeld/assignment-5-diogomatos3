## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
    bool "ldd"
    help
      This package installs the misc-modules and scull kernel modules into the root filesystem.
```
